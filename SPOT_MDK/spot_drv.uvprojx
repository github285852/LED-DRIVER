# Keil uVision project spot_drv.uvprojx, settings and files
target SPOT (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103RC STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.0.5
  cpu: IRAM(0x20000000,0xC000) IROM(0x08000000,0x40000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: spot_drv
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F10X_HD,USE_STDPERIPH_DRIVER,SPOT
  c include: ..\Source\APP;..\Source\CORE;..\Source\Driver;..\Source\Spot;..\Source\STM32F10x_FWLib\inc;..\Source\SYSTEM\sys;..\Source\SYSTEM\delay;..\Source\USER
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group USER
    ../Source/USER/: main.c stm32f10x_it.c system_stm32f10x.c
    ../Source/APP/: includes.h
  group APP
    ../Source/APP/: neuralpid.c PID.c scheduler.c
  group CORE
    ../Source/CORE/: core_cm3.c startup_stm32f10x_hd.s
  group DRIVER
    ../Source/Driver/: adc.c dmx512.c malloc.c ledpower.c PWM16.c stmflash.c wdg.c debug.c
    ../Source/SYSTEM/sys/: sys.c
    ../Source/SYSTEM/delay/: delay.c
  group LIB
    ../Source/STM32F10x_FWLib/src/: misc.c stm32f10x_adc.c stm32f10x_crc.c stm32f10x_exti.c stm32f10x_dma.c stm32f10x_flash.c stm32f10x_gpio.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_tim.c stm32f10x_wwdg.c stm32f10x_usart.c
  group SPOT
    ../Source/Spot/: spot.c
